SUMMARY = "Test Global variable"
DESCRIPTION = "Test Global variable"
LICENSE = "CLOSED"
