FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://psplash-img.h"
